# IAR project Lab3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: PART_LM3S8962
  ICCARM.CCIncludePath2: C:\StellarisWare\boards\ek-lm3s8962; C:\StellarisWare; C:\StellarisWare\boards
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: advanced_display.c advanced_display.h display.c display.h keypad.c keypad.h main.c rit128x96x4.c startup.c
    driverlib/: cpu.c cpu.h driverlib-cm3.sgxx
